Commit message: ver3.2.0 静态流水线机器人完整版本，动态流水线刚开始做，传感器思路

File: Webots_PR2_Path_Planning/protos/pr2/pr2.urdf (robot description, URDF)
Before this commit: robot pr2, 50 links, 49 joints
Joints:
- joint base_footprint_joint: origin xyz=0 0 0.051 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0
